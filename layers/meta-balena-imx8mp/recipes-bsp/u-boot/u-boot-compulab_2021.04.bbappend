UBOOT_KCONFIG_SUPPORT = "1"
inherit resin-u-boot
