SRC_URI = "git://github.com/nxp-imx-support/imx_sec_apps.git;protocol=https;branch=master"
