TTYS=" ttymxc1"
