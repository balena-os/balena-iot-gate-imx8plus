include balena-image.inc

BALENA_BOOT_SIZE="80960"
