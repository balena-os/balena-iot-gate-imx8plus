# package files as needed by the usrmerge feature
FILES:${PN} += "${nonarch_base_libdir}/optee_armtz/"
