# Declare that the balena package satisfies virtual-containerd
RPROVIDES:${PN} += "virtual-containerd"
